# Keil uVision project Sensorless_FOC.uvprojx, settings and files
target TLE9879 EvalKit (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TLE9879QXA40 Infineon
  pack: Infineon.TLE987x_DFP.1.6.0
  cpu: IRAM(0x18000000,0x1800) IROM(0x11000000,0x1EFFC) IROM2(0x1101EFFC,0x1004) CPUTYPE("Cortex-M3") CLOCK(40000000) ELITTLE
  output: Sensorless_FOC +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: .\emo;.\app
  memory RVCT4: ROM 0x11010000 size 0x8000
  memory RVCT5: ROM 0x1101e000 size 0x1000
  memory RVCT9: RAM 0x18000000 size 0x1800
  group app
    ./app/: Main.c globvars_FOC.c globvars_FOC.h commands.c commands.h
    ../: auto_address.c auto_address.h common.c common.h commonMC.c commonMC.h
  group emo
    ./emo/: Emo.c Emo_cfg.c Emo_RAM.c Table.c
software components: CMSIS:CORE 5.0.1, Device:ConfigWizard 1.8.6, Device:SDK:ADC1 0.1.6, Device:SDK:ADC2 0.1.6, Device:SDK:BDRV 0.3.6, Device:SDK:BOOTROM 0.2.1, Device:SDK:CCU6 0.2.3, Device:SDK:CSA 0.1.1, Device:SDK:GPT12E 0.1.4, Device:SDK:INT 0.1.4, Device:SDK:ISR 0.2.0, Device:SDK:MON 0.1.2, Device:SDK:PORT 0.5.2, Device:SDK:SCU 0.3.1, Device:SDK:SSC 0.1.2, Device:SDK:WDT1 0.2.6, Device:Startup 1.0.0

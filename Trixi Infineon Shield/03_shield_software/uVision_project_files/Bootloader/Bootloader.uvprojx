# Keil uVision project Bootloader.uvprojx, settings and files
target TLE9879_EvalKit (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TLE9879QXA40 Infineon
  pack: Infineon.TLE987x_DFP.1.3.2
  cpu: IRAM(0x18000000,0x1800) IROM(0x11000000,0x1EFFC) IROM2(0x1101EFFC,0x1004) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x11000000 size 0x1effc
  memory RVCT5: ROM 0x1101effc size 0x1004
  memory RVCT9: RAM 0x18000000 size 0x1800
  group App
    ./app/: main.c commands.c commands.h
    ../: auto_address.c auto_address.h common.c common.h
software components: CMSIS:CORE 5.0.2, Device:ConfigWizard 1.8.6, Device:SDK:ADC1 0.1.6, Device:SDK:BOOTROM 0.2.1, Device:SDK:INT 0.1.4, Device:SDK:ISR 0.2.0, Device:SDK:PORT 0.5.2, Device:SDK:SCU 0.3.1, Device:SDK:SSC 0.1.2, Device:SDK:WDT1 0.2.6, Device:Startup 1.0.0

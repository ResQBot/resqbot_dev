# Keil uVision project BldcBcHall.uvprojx, settings and files
target TLE9879 EvalKit (5060960::V5.06 update 7 (build 960)::.\ARMCLANGv5)
  device: TLE9879QXA40 Infineon
  pack: Infineon.TLE987x_DFP.1.6.0
  cpu: IRAM(0x18000000,0x1800) IROM(0x11000000,0x1EFFC) IROM2(0x1101EFFC,0x1004) CPUTYPE("Cortex-M3") CLOCK(40000000) ELITTLE
  output: BldcBcHall +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: .\emo;.\app
  memory RVCT4: ROM 0x1100a000 size 0x5000
  memory RVCT5: ROM 0x1101d000 size 0x1000
  memory RVCT9: RAM 0x18000000 size 0x1800
  group app
    ./app/: Main.c globvas_HALL.c globvars_HALL.h commands.c commands.h
    ../: auto_address.c auto_address.h common.c common.h commonMC.c commonMC.h
  group emo
    ./emo/: Emo.c EmoCcu.c EmoCcu_Cfg.c
software components: CMSIS:CORE 5.6.0, Device:SDK:ADC1 0.3.0, Device:SDK:BDRV 0.6.1, Device:SDK:BOOTROM 0.3.3, Device:SDK:CCU6 0.4.1, Device:SDK:GPT12E 0.2.2, Device:SDK:INT 0.2.3, Device:SDK:ISR 0.2.9, Device:SDK:PORT 0.6.0, Device:SDK:SCU 0.5.7, Device:SDK:SSC 0.1.8, Device:SDK:WDT1 0.3.3, Device:Startup 1.2.0
